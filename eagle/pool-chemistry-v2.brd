# Repository rhbroberg/-pool-chemistry

## EAGLE design eagle/pool-chemistry-v2.brd

Parts:
AP3602A-ORP, AP3602A-PH: MA04-1
BAT: PINHD-1X2; 1X02
C1, C2, C3, C5: 0.1; C1206
C4: 47; C1206
ESPWROOM: ESP-WROOM-32
JTAG: MA04-1
L1K: 1k; M1206
LDO: MCP1703CB; SOT23
LED1: LEDCHIPLED_1206; CHIPLED_1206
O10: 10k; M1206
O15: 15k; M1206
ORP: MA03-1
P1, P10: 10k; M1206
P15: 15k; M1206
PAD1, PAD2: SMD5; SMD2,54-5,08
PH: MA03-1
PU: 4.7k; M1206
TDS: MA03-1
TEMP: MA03-1
UART: MA04-1

Connections:
ENABLE: C5.1, ESPWROOM.3 (EN), P1.1
GND: AP3602A-ORP.3, AP3602A-PH.3, BAT.1, C1.1, C2.1, C3.2, C4.2, C5.2, ESPWROOM.1 (GND), ESPWROOM.15 (GND), ESPWROOM.38 (GND), L1K.2, LDO.1 (GND), O15.2, ORP.1, P15.2, PH.1, TDS.1, TEMP.1, UART.3
LED: ESPWROOM.24 (IO2), LED1.A
unnamed: L1K.1, LED1.C
ORP+5: AP3602A-ORP.2, ORP.2
ORPDATA: C2.2, ESPWROOM.7 (IO35), O10.2, O15.1
ORPEN: AP3602A-ORP.1, ESPWROOM.26 (IO4)
ORPSIG: O10.1, ORP.3
PH+5: AP3602A-PH.2, PH.2
PHDATA: C1.2, ESPWROOM.9 (IO33), P10.2, P15.1
PHEN: AP3602A-PH.1, ESPWROOM.10 (IO25)
PHSIG: P10.1, PH.3
RX: ESPWROOM.34 (RXD0), UART.2
TCK: ESPWROOM.16 (IO13), JTAG.2
TDI: ESPWROOM.14 (IO12), JTAG.1
TDO: ESPWROOM.23 (IO15), JTAG.4
TDSEN: ESPWROOM.11 (IO26), TDS.2
TDSSIG: ESPWROOM.8 (IO32), TDS.3
TEMPSIG: ESPWROOM.27 (IO16), PU.1, TEMP.3
TMS: ESPWROOM.13 (IO14), JTAG.3
TOUCH1: ESPWROOM.12 (IO27), PAD1.1
TOUCH2: ESPWROOM.25 (IO0), PAD2.1
TX: ESPWROOM.35 (TXD0), UART.1
VDD: C3.1, C4.1, ESPWROOM.2 (3V3), LDO.2 (VO), P1.2, PU.2, TEMP.2, UART.4
VSS: AP3602A-ORP.4, AP3602A-PH.4, BAT.2, LDO.3 (VI)

Board: 2 copper layers, 38.7 x 31.8 mm, 26 parts (9 on the bottom side), 25 nets.

## Commit log

2020-03-28 wrapped OTA 'push' interface into library
2020-03-30 added WDT; fixed syntax error in PushOTA
2020-03-30 initial Eagle files commit; smd devices placed but not routed
2020-03-31 discrete components placed and routed
2020-03-31 added missing labels to voltage divided signals
2020-03-31 clean files
2020-03-31 added ph, orp and esp ground caps
2020-03-31 added larger touch pads and LDO
2020-04-01 updated label content and locations
2020-04-02 power and LDO labeling
2020-04-04 oshpark review changes for board - manufactured
2020-04-04 watchdog properly working
2020-04-21 push OTA mode now activated by touchpin
2020-05-03 initial 3d enclosure
2020-05-03 updates to design with fixes from first manufacturing run
